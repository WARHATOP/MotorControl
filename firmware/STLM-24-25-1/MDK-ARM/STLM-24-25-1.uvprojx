# Keil uVision project STLM-24-25-1.uvprojx, settings and files
target STLM-24-25-1 (6240000::V6.24::ARMCLANG)
  device: STM32F303RETx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.3.0.0
  cpu: IRAM(0x20000000-0x2000FFFF) IRAM2(0x10000000-0x10003FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STLM-24-25-1 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F303xE
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../MCSDK_v6.4.1-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v6.4.1-Full/MotorControl/MCSDK/MCLib/F3xx/Inc;../Drivers/CMSIS/Device/ST/STM32F3xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP/Include
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x10000000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f303xe.s
  group Application/User
    ../Src/: main.c motorcontrol.c speed_torq_ctrl.c pwm_common.c mc_api.c mc_config.c mc_config_common.c mc_tasks.c mc_tasks_foc.c pwm_curr_fdbk.c regular_conversion_manager.c mc_math.c mc_interface.c stm32_mc_common_it.c stm32f30x_mc_it.c mc_parameters.c mc_configuration_registers.c mc_app_hooks.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c stm32f3xx_hal_uart.c stm32f3xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Middlewares/MotorControl
    ../MCSDK_v6.4.1-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c trajectory_ctrl.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c virtual_speed_sensor.c
    ../MCSDK_v6.4.1-Full/MotorControl/MCSDK/MCLib/F3xx/Src/: r3_2_f30x_pwm_curr_fdbk.c
software components: CMSIS:CORE 6.1.1
